## boards/shields/mykeebie/Kconfig.defconfig
```kconfig
if SHIELD_MYKEEBIE

config ZMK_KEYBOARD_NAME
    default "mykeebie"

endif # SHIELD_MYKEEBIE
```
